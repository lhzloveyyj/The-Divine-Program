# Keil uVision project AT32F435CGU7_WorkBench.uvprojx, settings and files
target AT32F435CGU7_WorkBench (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.7
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F435CGU7_WorkBench +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_i2s.c wk_qspi.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_spi.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
